v {xschem version=3.1.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/97ms/uci/ip/dac/1.schematics/3bit_dac.sym} 40 -70 0 0 {}
C {/home/97ms/uci/ip/dac/1.schematics/3bit_dac.sym} 40 80 0 0 {}
